# Keil uVision project STC8.uvproj, settings and files
target STC8 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Geek_STC8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\App;.\ChipDevices;.\ISR;.\UserDevices
  link misc: REMOVEUNUSED
  group User
    ./User/: main.c System_init.c isr.asm
  group App
    ./App/: Led1.c
    ./APP/: WaterLight.c app.c
  group ChipDevice
    ./ChipDevices/: ADC.c compare.c delay.c EEPROM.c Exti.c GPIO.c I2C.c PCA.c PWM.C PWM15bit.c Soft_UART.c spi.c timer.c UART.C WDT.c
  group UserDevice
    ./UserDevices/: Geek_Task.c
