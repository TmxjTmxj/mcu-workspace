# Keil uVision project firmware.uvproj, settings and files
target Simulator (MCS-51)
  device: 8052 Intel
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(11059200) MODP2
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: LED_BIT=1
  c include: .
  group User
    ./: main.c
