# Keil uVision project firmware.uvproj, settings and files
target STC8 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .
  link misc: REMOVEUNUSED
  group User
    ./: main.c
